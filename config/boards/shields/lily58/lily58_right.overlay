&oled_128x64 {
    reverse-mode;        /* попробуйте это свойство */
    /* segment-remap;    закомментируйте, если пробуете reverse-mode */
    /* com-invdir;       закомментируйте */
};